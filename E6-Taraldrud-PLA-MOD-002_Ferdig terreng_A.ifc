Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture]
Time: 2025-02-13T11:01:05
Author: CAZE
Written by: EDMsix Version 602.28.129 Aug 2 2022
Made in: Autodesk Civil 3D 2024 - English Build 13.6.342.0
Comment: STEP Physical File produced by: EDMsix Version 602.28.129 Aug 2 2022 * Module: EDMstepFileFactory v4.0.1/EDMstandAlone * Creation date: 20250213 11:01:05 * Host: NO-PF511CVX.ramboll.ramboll-group.global.network * Database: C:\Users\caze\AppData\Local\Temp\ACAIFCTMP/EDM11440\aec_ifc_db * Database version: 6007 * Database creation date: Thu Feb 13 10:48:47 2025 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Thu Feb 13 11:01:04 2025 * Header model: DataRepository.AecIfc_Header * Header model creation date: Thu Feb 13 11:01:04 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 10522 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, taraldrud
LongName: f-landskap
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcSite
RefLatitude: 69, 29, 43, 783784; RefLongitude: 10, 30, 0, 0; RefElevation: 0 m

# IfcBuilding, f-landskap
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
